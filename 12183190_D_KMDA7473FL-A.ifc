Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-10-19T10:23:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 19 10:23:55 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\dfb542ee-6696-4c3b-b0f2-c33118c40054\2c3f9b0e-f16e-4c1d-aef4-f049530b31cf\ifc * Database version: 5507 * Database creation date: Wed Oct 19 10:23:54 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 19 10:23:55 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 19 10:23:55 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12183190_D_KMDA7473FL-A:26747378_D_12183190_KMDA7473FL-A, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 26747378_D_12183190_KMDA7473FL-A
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 26747378_D_12183190_KMDA7473FL-A
Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_OBSW
Pset_BuildingElementProxyCommon - sets with these values: 2
